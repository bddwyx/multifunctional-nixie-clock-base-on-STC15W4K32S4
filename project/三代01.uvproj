# Keil uVision project 三代01.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 三代01 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user\inc;..\drivers\inc;..\main
  group Source Group 1
    ../startup/: STARTUP.A51
    ../main/: main.c
  group drivers
    ../drivers/src/: 74hc595.c buzz.c DS1302.c ISP_IAP_STC15W4K32S4.c pwm.c UART.c VS1838B.c
  group user
    ../user/src/: 5050rgb.c alarm_set.c infrared.c ini.c overflow.c uart_translate.c
  group explanations
    ../explaination(s)/: timer.txt 要做的事.txt
