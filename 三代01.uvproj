# Keil uVision project 三代01.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 三代01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./driver+user/: main.c
  group driver
    ./driver+user/: 74hc595.c DS1302.c UART.c buzz.c ISP_IAP_STC15W4K32S4.c VS1838B.c pwm.c
  group user
    ./driver+user/: alarm_set.c overflow.c uart_translate.c ini.c infrared.c 5050rgb.c
  group explanations
    ./explaination(s)/: timer.txt 要做的事.txt
